INITRAMFS_FSTYPES = "cpio.gz"
