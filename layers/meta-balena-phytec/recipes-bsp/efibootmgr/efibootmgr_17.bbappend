# Master branch was renamed to main
SRC_URI:remove = "git://github.com/rhinstaller/efibootmgr.git;protocol=https;branch=master"
SRC_URI:append = "git://github.com/rhinstaller/efibootmgr.git;protocol=https;branch=main"
