INTERNAL_DEVICE_KERNEL:phyboard-lyra-am62xx-2 = "mmcblk0"
