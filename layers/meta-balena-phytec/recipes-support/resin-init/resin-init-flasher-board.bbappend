FILESEXTRAPATHS:append:phyboard-lyra-am62xx-2 := "${THISDIR}/${PN}-phyboard-lyra-am62xx-2"

RDEPENDS:${PN}:append:phyboard-lyra-am62xx-2 = " mmc-utils"
