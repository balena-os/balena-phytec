# Restore default value removed in meta-phytec and needed by Balena
KERNEL_ARTIFACT_LINK_NAME="${MACHINE}"
