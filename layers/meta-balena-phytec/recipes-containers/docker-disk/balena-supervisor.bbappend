LED_FILE:phyboard-lyra-am62xx-2 = "/sys/class/leds/led-1/brightness"
